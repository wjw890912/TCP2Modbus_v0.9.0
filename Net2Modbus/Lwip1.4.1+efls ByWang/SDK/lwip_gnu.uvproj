# Keil uVision project lwip_gnu.uvproj, settings and files
target iap_lwip2modbus (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: lwip_gnu +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\myself\inc;..\GNU源码\lwip-1.4.1\src\include;..\GNU源码\lwip-1.4.1\src\include\lwip;..\GNU源码\lwip-1.4.1\src\include\ipv4;..\GNU源码\lwip-1.4.1\src\include\netif;..\GNU源码\lwip-1.4.1\test\unit;..\GNU源码\lwip-1.4.1\archport;..\GNU源码\lwip-1.4.1\archport\port;..\efsl\include;..\efsl\include\interface;..\httpserver_raw\inc;..\smtp;..\modbus\freemodbus-v1.6.0\modbus\include;..\modbus\freemodbus-v1.6.0\port;..\modbus\freemodbus-v1.6.0\modbus\rtu;..\modbus\User;..\Libraries\STM32_ETH_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\flash\inc;..\iap\inc;..\SI4432Protocol;..\SI4432_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../myself/src/: netconf.c stm32f10x_it.c stm32f107.c client_tcpudp.c filesystem.c DS18B20SROM.c ds18b20sech.c main.c
    ../netbios/: netbios.c
    ../tftp/: tftpserver.c tftputils.c
  group chip_dev_lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group eth_dev
    ../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group lwip_core
    ../GNU源码/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c timers.c
    ../GNU源码/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip_api
    ../GNU源码/lwip-1.4.1/src/api/: api_lib.c err.c tcpip.c netifapi.c netdb.c netbuf.c
  group lwip_netif
    ../GNU源码/lwip-1.4.1/src/netif/: etharp.c
  group lwip_port
    ../GNU源码/lwip-1.4.1/archport/port/: ethernetif.c
  group cpu
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group efsl/core
    ../efsl/source/: dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
  group efsl/interface
    ../efsl/source/interface/: sd.c sd_stm32.c
  group http
    ../httpserver_raw/src/: fsdata.c httpd.c fs_lwip.c
  group smtp
    ../smtp/: smtp.c snmp_app.c
  group readme
    ../../: readme.txt
  group modbus
    ../modbus/freemodbus-v1.6.0/modbus/: mb_m.c
  group modbus/rtu
    ../modbus/freemodbus-v1.6.0/modbus/rtu/: mbrtu_m.c mbcrc.c
  group modbus/app
    ../modbus/User/: modbus_main.c usart.c
  group modbus/include
    ../modbus/freemodbus-v1.6.0/modbus/include/: mb.h mb_m.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group modbus/port
    ../modbus/freemodbus-v1.6.0/port/: porttimer_m.c portserial_m.c portevent_m.c port.c
  group flash
    ../flash/src/: flash_if.c
  group iap
    ../iap/src/: tftpserver_iap.c main_iap.c
  group rfsys-potolay
    ../SI4432Protocol/: SI4432_proto.c
  group rfsys-dev
    ../SI4432_Driver/: SI4432.c SI4432RFConfig.c
